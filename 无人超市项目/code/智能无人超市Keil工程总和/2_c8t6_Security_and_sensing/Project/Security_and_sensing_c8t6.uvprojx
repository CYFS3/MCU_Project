# Keil uVision project Security_and_sensing_c8t6.uvprojx, settings and files
target Security_and_sensing_c8t6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Security_and_sensing_output +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Source\Main;..\Source\Dev;..\Source\Cdh_stm32;..\Source\Use;..\Source\System;..\Source\Sensor;..\Source\Lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Cdh_helper
    ../Source/Cdh_stm32/: cdh_fun_stm32.c data_helper.c
  group System
    ../Source/System/: config.h system.c systick.c task.c
  group Main
    ../Source/Main/: main.c stm32f10x_conf.h stm32f10x_it.c
  group Dev
    ../Source/Dev/: usart.c timer.c adc.c
  group Use
    ../Source/Use/: led.c to_main_zet6.c
  group Sensor
    ../Source/Sensor/: dht11.c light.c fire.c beep.c smoke_MQ.c big_led.c fan.c
  group Lcd
    ../Source/Lcd/: lcd.c lcd_init.c lcdfont.h pic.h sensor_lcd.c
