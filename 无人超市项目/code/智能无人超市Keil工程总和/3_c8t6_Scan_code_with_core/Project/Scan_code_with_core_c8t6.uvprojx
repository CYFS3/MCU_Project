# Keil uVision project Scan_code_with_core_c8t6.uvprojx, settings and files
target Scan_code_with_core_c8t6 (5050106::V5.05 update 1 (build 106)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Scan_code_with_core_output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Source\Main;..\Source\Dev;..\Source\Cdh_stm32;..\Source\System;..\Source\DataGoods;..\Source\Payment;..\Source\Use
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Cdh_helper
    ../Source/Cdh_stm32/: cdh_fun_stm32.c data_helper.c cJSON.c
  group System
    ../Source/System/: config.h system.c systick.c task.c
  group Dev
    ../Source/Dev/: usart.c timer.c adc.c RemapGPIO.h
  group DataGoods
    ../Source/DataGoods/: Goods.h Goods.c User.c User.h
  group Payment
    ../Source/Payment/: Openmv.c Openmv.h spi.c spi.h w25qxx.c w25qxx.h Uasrttft.c Usarttft.h Servo.c Servo.h ScanCode.c ScanCode.h order.c
  group Main
    ../Source/Main/: main.c stm32f10x_conf.h stm32f10x_it.c
  group use
    ../Source/Use/: led.c
