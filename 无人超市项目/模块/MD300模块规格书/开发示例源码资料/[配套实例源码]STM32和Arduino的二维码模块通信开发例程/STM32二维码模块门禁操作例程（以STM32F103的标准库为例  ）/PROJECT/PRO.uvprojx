# Keil uVision project PRO.uvprojx, settings and files
target PRO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PRO +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\DRIVER;..\STLibraries\inc;..\USR;..\NET
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USR
    ../USR/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DRIVER
    ../DRIVER/DELAY/: Delay.c
    ../DRIVER/LED/: LED.c LED.h
    ../DRIVER/NVIC/: NVIC.c
    ../DRIVER/UART/: uart.c
  group STLibraries
    ../STLibraries/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group DOC
    ../DOC/: doc.txt
  group NET
    ../NET/: NetWork.c NetWork.h
